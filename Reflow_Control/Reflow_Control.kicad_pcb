# Repository polymurph/Reflow-Oven

File README.md:

# Reflow-Oven
Reflow Oven Hardware KiCAD Projects

# Firmware

- implement interface with simple polymorphism

## KiCad design Reflow_Control/Reflow_Control.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C1, C3, C5, C6, C7, C8, C9, C10, C11, C12, C13: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 100uF; CP_Elec_5x5.4
C14, C15: 100uF; CP_Elec_8x6.2
D1, D2, D3, D4, D5: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.5mm_Pad
H7, H8, H9, H10: MountingHole; MountingHole_3mm_Pad_Via
J1: Conn_5V; PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal
J2: Conn_ssr_1; PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal
J3: Conn_ssr_2; PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal
J4: Conn_mot_PWR; PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal
J5: Conn_mot_1; PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal
J6: Conn_mot_2; PhoenixContact_MC_1,5_2-G-5.08_1x02_P5.08mm_Horizontal
JP1: 3.3V Jumper; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2, JP3, JP4: ADDR_A2; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
Q1, Q2: NUD3112LT1G; SOT-23_Handsoldering
Q3: BC848; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8, R9: 4k7; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R10, R11, R12, R15: 1k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1, SW2, SW3, SW4, SW6, SW7, SW8: SW_Push; SW_SPST_B3S-1000
SW5: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E_Vertical_H20mm
U1: SSD1306_128x64; PinHeader_1x04_P2.54mm_Vertical
U2: NUCLEO-F042K6; Arduino_Nano
U3: MAX31865_Breakout; PinHeader_1x08_P2.54mm_Vertical
U4: LM1117-3.3; SOT-223
U5: PCA9555; SOIC-24W_7.5x15.4mm_P1.27mm
U6: TB6612FNG_C_8_EL; LSSOP-24_W5.6mm; MPN TB6612FNG,C,8,EL; Digi-Key_PN TB6612FNGC8ELCT-ND

Connections:
+3V3: BZ1.1 (-), C2.2, C4.1, J2.2, J3.2, JP1.2 (B), JP2.1 (A), JP3.1 (A), JP4.1 (A), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R10.1, R11.1, R12.1, U1.2 (VCC), U3.3 (3V3), U4.2 (VO), U5.24 (VCC), U6.20
+5V: C3.1, J1.1, U2.27 (5V), U4.3 (VI)
/motor_vcc: C14.1, C15.1, J4.1, U6.13, U6.14, U6.24
ADDR_A0: JP4.2 (C), U5.21 (A0)
ADDR_A1: JP3.2 (C), U5.2 (A1)
ADDR_A2: JP2.2 (C), U5.3 (A2)
BTN_A: C12.1, SW7.1, U5.4 (IO0_0)
BTN_B: C13.1, SW8.1, U5.9 (IO0_5)
BTN_CENTER: C7.1, SW4.1, U5.7 (IO0_3)
BTN_DOWN: C5.1, SW2.1, U5.6 (IO0_2)
BTN_LEFT: C6.1, SW3.1, U5.5 (IO0_1)
BTN_RIGHT: C11.1, SW6.1, U5.10 (IO0_6)
BTN_UP: C1.1, SW1.1, U5.8 (IO0_4)
CH1_MOTOR_IN1: U2.11 (D8), U6.21
CH1_MOTOR_IN2: U2.10 (D7), U6.22
CH1_MOTOR_STBY: U2.12 (D9), U6.19
CH2_MOTOR_IN1: U2.5 (D2), U6.16
CH2_MOTOR_IN2: U2.13 (D10), U6.17
ENC_Switch: C8.2, SW5.S1, U5.11 (IO0_7)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, J1.2, J4.2, JP2.3 (B), JP3.3 (B), JP4.3 (B), Q1.2 (S), Q2.2 (S), Q3.2 (E), R7.2, R8.2, R9.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.C, SW5.S2, SW6.2, SW7.2, SW8.2, U1.1 (GND), U2.4 (GND), U2.29 (GND), U3.2 (GND), U4.1 (GND), U5.12 (VSS), U6.3, U6.4, U6.9, U6.10, U6.18
I2C1_SCL: R2.2, U1.3 (SCL), U2.8 (D5), U5.22 (SCL)
I2C1_SDA: R1.2, U1.4 (SDA), U2.7 (D4), U5.23 (SDA)
INT_ENC_A: C10.2, R6.2, SW5.B, U2.19 (A0)
INT_ENC_B: C9.2, R5.2, SW5.A, U2.20 (A1)
INT_MAX31865_RDY: R3.2, U2.21 (A2), U3.8 (RDY)
INT_PCA9555: R4.2, U2.25 (A6), U5.1 (INT)
unnamed: BZ1.2 (+), Q3.3 (C), R12.2
unnamed: D1.1 (K), R7.1
unnamed: D1.2 (A), U5.18 (IO1_5)
unnamed: D2.1 (K), R8.1
unnamed: D2.2 (A), U5.19 (IO1_6)
unnamed: D3.1 (K), R9.1
unnamed: D3.2 (A), U5.20 (IO1_7)
unnamed: D4.1 (K), J2.1, Q1.3 (D)
unnamed: D4.2 (A), R10.2
unnamed: D5.1 (K), J3.1, Q2.3 (D)
unnamed: D5.2 (A), R11.2
unnamed: J5.1, U6.1, U6.2
unnamed: J5.2, U6.5, U6.6
unnamed: J6.1, U6.7, U6.8
unnamed: J6.2, U6.11, U6.12
unnamed: JP1.1 (A), U2.17 (3V3)
unnamed: Q3.1 (B), R15.1
SPI1_CS_MAX31865: U2.24 (A5), U3.7 (CS)
SPI1_MISO: U2.15 (D12), U3.5 (SDO)
SPI1_MOSI: U2.14 (D11), U3.6 (SDI)
SPI1_SCK: U2.16 (D13), U3.4 (CLK)
SSR_1: Q1.1 (G), U2.23 (A4)
SSR_2: Q2.1 (G), U2.26 (A7)
TIM1_CH1_PWM_Buzzer: R15.2, U2.22 (A3)
TIM3_CH1_MOTOR_PWM: U2.9 (D6), U6.23
TIM3_CH2_MOTOR_PWM: U2.6 (D3), U6.15

Notes on the sheet:
MCU
RTD breakout board
1.1" Oled lcd
I/O Expander
User I/O
Mounting holes
Buzzer for sound
LDO 3.3V
DC motor control

Board: 2 copper layers, 100.0 x 80.0 mm, 71 parts (0 on the bottom side), 52 nets.

## Code that names these connections

File STCube/STCube.ioc (part):

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Mcu.UserName=STM32F042K6Tx
PA15.GPIOParameters=GPIO_Label
PA14.GPIO_Label=SWCLK
PA0.GPIO_Label=INT_ENC_A
PA11.GPIOParameters=GPIO_Label
PA3.GPIOParameters=GPIO_Label
PA11.GPIO_Label=SPI_CS_MAX31865
boardIOC=true
PA2.GPIOParameters=GPIO_Label
PA13.Signal=SYS_SWDIO
PA15.GPIO_Label=VCP_RX
PB6.Signal=I2C1_SCL
PB6.Mode=I2C
PA1.Signal=GPXTI1
PF0-OSC_IN.Mode=HSE-External-Clock-Source
PF0-OSC_IN.GPIO_Label=MCO
PB3.Mode=Full_Duplex_Master
board=NUCLEO-F042K6
PA15.Mode=Asynchronous
PA1.GPIOParameters=GPIO_Label
PB4.Mode=Full_Duplex_Master
PA14.Mode=Serial_Wire
PB5.Mode=Full_Duplex_Master
PA1.GPIO_Label=INT_ENC_B
PB7.Signal=I2C1_SDA
PA8.Signal=S_TIM1_CH1
PA13.Mode=Serial_Wire
Mcu.Name=STM32F042K(4-6)Tx
PA2.Signal=USART2_TX
PA13.GPIO_Label=SWDIO
PA0.Signal=GPXTI0
PA13.GPIOParameters=GPIO_Label
PB3.Signal=SPI1_SCK
Mcu.Package=LQFP32
PB5.Signal=SPI1_MOSI
PA6.Signal=S_TIM3_CH1
PA14.GPIOParameters=GPIO_Label
PA2.GPIO_Label=VCP_TX
PA11.Signal=GPIO_Output
PB7.Mode=I2C
PA10.Signal=S_TIM1_CH3
PA14.Signal=SYS_SWCLK
PA15.Signal=USART2_RX
PA0.GPIOParameters=GPIO_Label
PA2.Mode=Asynchronous
PF0-OSC_IN.Signal=RCC_OSC_IN
PF0-OSC_IN.GPIOParameters=GPIO_Label
PB4.Signal=SPI1_MISO
PA3.GPIO_Label=INT_MAX31865_RDY
PA3.Signal=GPXTI3

## Commit log

2020-09-25 inital KiCAD project
2020-09-25 work on schematic
2020-10-24 work on Buzzer
2020-10-24 work on push buttons
2020-10-24 work on rotary encoder
2020-10-24 work on IO expander
2020-10-24 work on display
2020-10-24 working on MAX31865
2020-11-21 connected Encoder to A0and A1(PA0, PA1)
2020-11-21 work on Schematic + added STMCubeMX for pin config
2020-11-21 work on naming
2020-11-21 naming signals
2020-11-29 Updated version with Edwin & Kerem 29.11.2020 Only Schema
2020-12-01 work on scematic
2020-12-05 added phoenix contact connector
2020-12-05 started with layout
2020-12-05 work on pcb layout
2020-12-05 placement of display
2020-12-05 work on pcb
2020-12-20 Kerem & Edwin dez. 20 2020 mitarbeit
2020-12-25 small changes to layout
2020-12-25 created gerber and bom files
2021-02-14 repaced NPN with nud3112 relay switcher
2021-05-21 added version + creators name
2021-05-21 added motor controller
2021-05-24 reviwewd ground planes connection
2021-05-24 created gerber files
2021-05-24 review gerber files + added JLC ordernumber location
2021-05-24 changed part attributes
2021-05-24 removed old files
2021-05-29 v1.0
2021-09-07 ignore .vscode
2021-09-07 ignore c / cpp stuff
2021-09-07 firmware inital
2021-09-11 work on firmware
2021-09-12 work on fsm
2021-09-13 work on fsm... does not comile
2021-09-13 bugfixing
2021-09-16 fsm bugfixes
2021-09-16 fsm compiles
2021-09-16 working fsm structure
2021-09-16 added sock state
2021-09-16 added ramp state
2021-09-16 added cooldown state
2021-09-16 basic fsm structure created
2021-09-16 added terminal clear
2021-09-18 working on multithreading
2021-09-19 code split
2021-09-27 cleanup project
2021-10-02 started writing the driver for MAX31865 sensor amp
2021-10-02 work on driver
2021-10-16 work on max31865 driver
2021-10-16 startedwith code structure
2021-10-28 crude ui
2021-10-28 working crude ui
2022-02-24 work on firmware structure test
2022-02-24 work on messaging between threads
